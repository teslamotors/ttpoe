## Config.in
```kconfig
config BR2_PACKAGE_MODTTP
        bool "modttp"
        help
          modttp implement ttp kernel modules - modttpoe and modttpip
```
